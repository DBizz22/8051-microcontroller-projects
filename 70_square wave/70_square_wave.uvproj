# Keil uVision project 70_square_wave.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: 70_square_wave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: wave.c
