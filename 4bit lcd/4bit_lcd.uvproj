# Keil uVision project 4bit_lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: T80C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: 4bit_lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 4bit.c
